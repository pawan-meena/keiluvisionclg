# Keil uVision project exp-8.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: exp-8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: exp-8.asm exp-8-1.asm
